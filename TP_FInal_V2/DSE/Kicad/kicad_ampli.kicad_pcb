# Repository MIDORIINU/Circuitos-2

File README.md:

# Circuitos-2
Repositorio para circuitos electrónicos 2 (66.10) - FIUBA

Irusta Pablo

Luna Diego

Niero Adrián

Romero Daniel

## KiCad design TP_FInal_V2/DSE/Kicad/kicad_ampli.kicad_pcb

Parts:
C1, C16: 1u; CP_Radial_D4.0mm_P2.00mm
C2, C3, C12, C13, C14, C15: 100u; CP_Radial_D8.0mm_P3.50mm
C4: 220p; C_1206_3216Metric
C5, C6: 470u; CP_Radial_D10.0mm_P5.00mm
C7, C8, C9, C10, C11: 10n; C_1206_3216Metric
C17: 100p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C18, C19: 1u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C20, C23, C24, C25: 22n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C21: 220n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C22: 2.2n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: LED; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm
D2, D7: DN4007; D_5W_P12.70mm_Horizontal
D3: D_Zener; D_DO-35_SOD27_P7.62mm_Horizontal
D4: DN4370 (zener); D_DO-35_SOD27_P7.62mm_Horizontal
D5, D6: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D8, D9: DN5822; D_DO-201AD_P15.24mm_Horizontal
J1: AudioJack2; ACJS-NH35
J2: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm_BELOW_W3DM
J3, J3(GND)1, J4, J5, J6, J7, J8: Conn_01x01_Male; PinHeader_1x01_P1.00mm_Vertical
JP1, JP5: Jumper; PinHeader_1x03_P2.54mm_Vertical
JP2, JP3, JP4: Jumper; PinHeader_1x02_P2.54mm_Vertical
Jack4: +15; BarrelJack_Horizontal
Jack5: -15; BarrelJack_Horizontal
Jack6: +30; BarrelJack_Horizontal
Jack7: -30; BarrelJack_Horizontal
Q1, Q3, Q5, Q6: BC546; TO-92_Inline
Q2, Q4, Q7, Q8: BC556; TO-92_Inline
Q9, Q12, Q13: BD135; TO-126-3_Vertical
Q10, Q11: BD136; TO-126-3_Vertical
Q14, Q15: Q_NPN_BCE; TO-264-3_Vertical
Q16, Q17: Q_PNP_BCE; TO-264-3_Vertical
Q18: 2N3906; TO-92_Inline_Wide
Q19: 2N3904; TO-92_Inline_Wide
R1, R12: 22k; R_1206_3216Metric
R2, R3: 4.7k; R_1206_3216Metric
R4, R8, R10: 220; R_1206_3216Metric
R5, R7: 56; R_1206_3216Metric
R9, R13: 22; R_1206_3216Metric
R11: 5k6; R_1206_3216Metric
R14, R28, R30: 10k; R_1206_3216Metric
R15: 2k7; R_1206_3216Metric
R16, R17, R18, R19: 100; R_1206_3216Metric
R20, R21: 0.1; R_Axial_Power_L20.0mm_W6.4mm_P30.48mm
R22, R24, R27: 100k; R_1206_3216Metric
R23, R29, R61, R62: 1k; R_1206_3216Metric
R25: 1M; R_1206_3216Metric
R26: 220k; R_1206_3216Metric
RV1: R_POT (1k); Potentiometer_ACP_CA6-H2,5_Horizontal_BELOW_W3DM
RV2: R_POT 2k; Potentiometer_ACP_CA6-H2,5_Horizontal_BELOW_W3DM
RV3, RV4, RV5: R_POT; Potentiometer_Alps_RK163_Single_Horizontal_W3DM
U1: LMH6609MA; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
GND: C5.1, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.1, C17.2, C23.2, C24.2, C25.1, J1.S, J2.1, J3(GND)1.1, Jack4.1, Jack5.1, Jack6.1, Jack7.1, R1.2, R2.1, R22.2, R24.1, R29.1, RV1.2, RV1.3, RV4.3; also elsewhere on the board
unnamed: C1.1, JP5.2
unnamed: C1.2, Q1.2 (B), R1.1
unnamed: C2.1, R2.2, R3.2
unnamed: C2.2, C5.2, D1.1 (K), D2.2 (A), R10.2, R62.2
unnamed: C3.1, Q5.2 (B), R12.2
unnamed: C3.2, R9.1
unnamed: C4.1, JP3.1
unnamed: C4.2, Q1.1 (C), Q2.1 (C), Q7.2 (B)
unnamed: C6.1, D7.1 (K), R4.1, R8.1, R11.1, R13.1
unnamed: C7.1, D4.2 (A), Q9.2 (C), Q13.3 (B), Q19.3 (C), R14.1
unnamed: C7.2, D3.1 (K), Q9.1 (E), Q10.3 (B), Q18.3 (C), RV2.2, RV2.3
unnamed: C10.1, C14.1, C24.1, D8.2 (A), J4.1, Jack4.2, U1.7
unnamed: C11.1, C15.2, C25.2, D9.1 (K), J5.1, Jack5.2, U1.4
unnamed: C8.1, C12.1, D7.2 (A), J6.1, Jack6.2, Q12.2 (C), Q14.2 (C)
unnamed: C9.1, C13.2, D2.1 (K), J7.1, Jack7.2, Q11.2 (C), Q17.2 (C)
unnamed: C16.1, JP1.2
unnamed: C16.2, R22.1, R23.1
unnamed: C17.1, R23.2, U1.3
unnamed: C18.1, C19.1, R27.2, U1.6
unnamed: C18.2, C19.2, C22.2, R28.2
unnamed: C20.1, C21.1, R30.2, RV3.2
unnamed: C20.2, R28.1, RV3.1
unnamed: C21.2, R29.2, RV3.3
unnamed: C22.1, RV5.3
unnamed 25: C23.1, RV5.1; also elsewhere on the board
unnamed: D1.2 (A), Q3.2 (B), Q6.2 (B), R3.1
unnamed: D3.2 (A), D6.1 (K), J8.1, Q6.1 (C)
unnamed: D4.1 (K), D5.2 (A), JP4.2
unnamed: D5.1 (K), Q12.3 (B)
unnamed: D6.2 (A), Q11.3 (B)
unnamed: D8.1 (K), Q13.2 (C), Q14.3 (E), Q15.2 (C), R17.2
unnamed: D9.2 (A), Q10.2 (C), Q16.2 (C), Q17.3 (E), R16.1
unnamed: J1.T, JP1.1
unnamed: J2.2, JP2.2, Q18.1 (E), Q19.1 (E), R18.2, R19.1, R20.2, R21.1
unnamed: J3.1, Q3.1 (C), R5.2, R7.2
unnamed: JP2.1, R12.1
unnamed: JP3.2, JP4.1, Q7.1 (C), Q8.1 (C)
unnamed: JP5.1, RV4.2
unnamed: Q1.3 (E), R5.1
unnamed: Q2.2 (B), Q4.1 (C), Q4.2 (B), Q5.1 (C)
unnamed: Q2.3 (E), R4.2
unnamed: Q3.3 (E), R61.1
unnamed: Q4.3 (E), R8.2
unnamed: Q5.3 (E), R7.1
unnamed: Q6.3 (E), R10.1
unnamed: Q7.3 (E), Q8.2 (B), R11.2
unnamed: Q8.3 (E), R13.2
unnamed: Q9.3 (B), R14.2, R15.1
unnamed: Q10.1 (E), Q16.1 (B), R19.2
unnamed: Q11.1 (E), Q17.1 (B), R16.2
unnamed: Q12.1 (E), Q14.1 (B), R17.1
unnamed: Q13.1 (E), Q15.1 (B), R18.1
unnamed: Q15.3 (E), Q19.2 (B), R20.1
unnamed: Q16.3 (E), Q18.2 (B), R21.2
unnamed: R9.2, RV1.1
unnamed: R15.2, RV2.1
unnamed: R24.2, R25.1, U1.2
unnamed: R25.2, R26.1
unnamed: R26.2, R27.1
unnamed: R30.1, RV4.1, RV5.2
unnamed: R61.2, R62.1

Board: 2 copper layers, 141.0 x 118.1 mm, 110 parts (13 on the bottom side), 62 nets.

Other parts of the board:
C23#2: 22n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J3(GND)1#2: Conn_01x01_Male; PinHeader_1x01_P1.00mm_Vertical

Their connections:
GND: C23#2.2, J3(GND)1#2.1; also elsewhere on the board
unnamed 25: C23#2.1; also elsewhere on the board

## KiCad design TP_Final/PCB/preamp_KICAD/Pre.kicad_pcb

Parts:
C1, C4, C5, C6, C7, C8, C9, C11: C; CP_Radial_D4.0mm_P1.50mm
C2, C3, C10: CP1; CP_Radial_D4.0mm_P1.50mm
J1: AudioJack3; Jack_3.5mm_CUI_SJ-3523-SMT_Horizontal
J2: Conn_01x03_Male; PinHeader_1x03_P1.00mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R10, R12, R13: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
RV1, RV2, RV3, RV4: R_POT; Potentiometer_Alps_RK09K_Single_Horizontal
U1, U2: NE5532; DIP-8_W10.16mm

Connections:
+5V: C5.1, C11.1, U1.8 (V+), U2.8 (V+)
-5V: U1.4 (V-), U2.4 (V-)
GND: C1.2, C5.2, C11.2, J1.T, J2.1, R2.2, R12.2, RV1.3, U1.5 (+), U2.3 (+), U2.5 (+), U2.6 (-)
unnamed: C1.1, C2.2, R1.1, R2.1
unnamed: C2.1, RV1.1
unnamed: C3.1, C4.2, R3.2
unnamed: C3.2, U1.1, U1.2 (-)
unnamed: C4.1, R4.2
unnamed: C6.1, C8.2, R7.2, RV3.2
unnamed: C6.2, R3.1, R5.2
unnamed: C7.2, RV2.1
unnamed: C8.1, R8.2, RV3.3
unnamed: C9.2, R6.2, R7.1, U1.6 (-)
unnamed: C10.1, R10.2
unnamed: C7.1, C9.1, C10.2, R8.1, U1.7
unnamed: J1.S, R1.2
unnamed: J2.3, R13.1
unnamed: R4.1, RV2.3
unnamed: R5.1, RV3.1
unnamed: R6.1, RV2.2
unnamed: R10.1, R12.1, RV4.3, U2.2 (-)
unnamed: R13.2, RV4.1, RV4.2, U2.1
unnamed: RV1.2, U1.3 (+)

Board: 2 copper layers, 30 parts (0 on the bottom side), 23 nets.

## KiCad design TP_FInal_V2/DSE/Fuente/kicad_fuente/kicad_fuente.kicad_pcb

Parts:
C1: 100u; CP_Radial_D8.0mm_P2.50mm
C2: 0.22u; C_1206_3216Metric
C3: 470u; CP_Radial_D12.5mm_P5.00mm
C4: 100u; CP_Elec_8x10
C5, C6, C7: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C8: 220u; CP_Elec_8x10
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D2: D_Schottky; D_DO-201AD_P15.24mm_Horizontal
D4: SK54B; D_2010_5025Metric_Pad1.52x2.65mm_HandSolder
Jout+1: Jack-DC; BarrelJack_Horizontal
L1: 150u; L_Toroid_Vertical_L19.1mm_W8.1mm_P7.10mm_Bourns_5700
L2: 33u; L_12x12mm_H8mm
Q1: 2N3906; TO-92_Inline
R1: 3k3; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R2, R31, R32: 100k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5: R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R6: 470; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R41, R42: 8k2; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
Rpot1: 10k; Potentiometer_Bourns_3296W_Vertical
U1: LM2577T-ADJ; TO-220-5_Vertical
U2: LM2596S-ADJ; TO-263-5_TabPin3
Vin1-1: Jack-DC; BarrelJack_Horizontal
Vin+1: Jack-DC; BarrelJack_Horizontal
Vout-1: Jack-DC; BarrelJack_Horizontal

Connections:
GND: C1.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, D2.1 (K), D4.2 (A), Jout+1.1, R6.2, R31.1, R32.1, U1.5 (~ON~/OFF), U2.3 (GND), U2.5 (~ON~/OFF), Vin1-1.1, Vin+1.1, Vout-1.1
unnamed: C2.1, R1.2
unnamed: C3.2, D1.2 (A), L1.2, Vout-1.2
unnamed: C6.1, C7.1, C8.1, Jout+1.2, L2.2, R5.2, Rpot1.1, Rpot1.2
unnamed: D1.1 (K), Q1.2 (B), R2.1
unnamed: D2.2 (A), L1.1, U1.4 (FB)
unnamed: D4.1 (K), L2.1, U2.2 (OUT)
unnamed: Q1.1 (E), R31.2, R32.2
unnamed: Q1.3 (C), R41.1, R42.1, U1.2 (OUT)
unnamed: R1.1, U1.1 (VIN)
unnamed: R5.1, R6.1, Rpot1.3, U2.4 (FB)
VCC: C4.1, C5.1, U2.1 (VIN), Vin+1.2
VSS: C1.2, C2.2, R2.2, R41.2, R42.2, U1.3 (GND), Vin1-1.2

Board: 2 copper layers, 96.5 x 97.8 mm, 29 parts (4 on the bottom side), 13 nets.

## Commit log

2019-04-02 Incio el repositorio
2019-04-03 Borro copia de las bibliotecas.
2019-04-03 Agrego template para el informe, con solo la carátula y algunos títulos.
2019-04-03 Actualizo encabezado de páginas.
2019-04-03 Correcciones.
2019-04-11 Puntos enumerados
2019-04-11 Subo simulación dinámica de carga
2019-04-11 Muevo los archivos extra al directorio del TP1A.
2019-04-11 Switch
2019-04-12 Modelos en el switch.
2019-04-15 Explicación de operacionales
2019-04-15 Agregadas las simulaciones de los puntos 6 y 7 y el modelo del LM723 para las últimas simulaciones.
2019-04-15 Agrego punto 15.
2019-04-15 Corrección.
2019-04-16 Agrego las hojas de datos de todos los dispositivos. Agrego el circuito para el punto 21, uso el mismo driver de corriente (el par compuesto), y ajusto los valores para tener la misma tensión de sali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
2019-04-16 Elimino circuitos obsoletos.
2019-04-16 Ajusto algunos nombres.
2019-04-16 Agregados puntos 13,14 y 20.
2019-04-16 Agrego salida del punto 13.
2019-04-16 Agrego salida del punto 14.
2019-04-16 Corrección punto 20.
2019-04-16 Puntos 18 y 19
2019-04-16 Agrego mas puntos.
2019-04-16 Agrego otros puntos y renombro algunos archivos.
2019-04-17 web para bajar componentes del ltspice
2019-04-17 Corregido el modelo del BC558, era el que causaba problemas, agregadas las redes de compensación y ajustadas todas las simulaciones, agregadas simulaciones para obtener los puntos de reposo en modo t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
2019-04-18 Agrego todas las simulaciones del punto 21.
2019-04-18 Agrego algunos scripts.
2019-04-19 Agrego mas scripts.
2019-04-19 simulacion 17 a y b
2019-04-19 Correción punto 20.
2019-04-19 Corrección al tiempo de simulación del punto 17.
2019-04-19 subo 20.b con directiva .meas para calculo de rechazo al ruido
2019-04-19 calcula los db de rechazo
2019-04-20 Agrego base P3,4,5
2019-04-20 Exapndo puntos 4 y 5.
2019-04-20 Correcciones a la simulación de la polarización.
2019-04-21 Agrego circuitos de medición de algunas resistencias de entrada y salida, y ganancias para verificar los cálculos manuales.
2019-04-21 Agrego medición de la gananacia del par compuesto, para ver su variación con el estado de carga.
2019-04-21 Agrego simulaciones para la medición de la ganancia y la resistencia de entrada del par Sziklai.
2019-04-22 Subo una versión muy preliminar del informe.
2019-04-23 Puntos 3 4 5
2019-04-23 Informe con todos los títulos.
2019-04-23 Subo los puntos 18, 19 y 20.
2019-04-24 Trabajando en punto 16.
2019-04-24 Completos todas las respuestas a las preguntas de simulación, salvo la 21.
2019-04-24 Completo el apéndice sobre la llave analógica y el punto 3, haciendo referencia a lo agregado.
2019-04-25 Escribiendo la explicación del par compuesto.
2019-04-25 Agrego imágenes.
2019-04-25 Agrego el apéndice sobre el apr Sziklai y correcciones.
2019-04-25 Correcciones
2019-04-25 Agregada la explicación del circuito de la referencia de tensión.
2019-04-26 Agrego una imagen para la explicación de diodos.
2019-04-26 Diodo PNG + XML
2019-04-26 Texto explicativo DIODO
2019-04-26 Diodo drawio
2019-04-26 Trabajando en operacionales.
2019-04-26 Lista la explicación del amplificador no inversor con operacionales.
2019-04-26 Faltaba agregar las imágenes.
2019-04-26 Completo el apéndice de operacionales, agregando lo de reguladores que escribió Daniel.
2019-04-26 Incorporando los temas de investigación.
2019-04-26 Punto 9 completo, sin agregar todavía lo del diodo, de Pablo, eso a lo último lo hago.
2019-04-26 Agrego simulación para verificar potencias.
2019-04-27 Punto10
2019-04-27 Agregado el cálculo de la ganancia a lazo abierto de la tensión.
2019-04-27 Ingresando lo último.
2019-04-27 Versión a la que solo le faltan unas imágenes.
2019-04-27 Almost.
2019-04-27 LISTO!!!!!!!!!!!!!!!.
2019-04-27 Recompilo.
2019-04-28 Inicio el repo del TP1B.
2019-04-28 Agrego el circuito base.
2019-04-28 OrgaPuntos
2019-04-28 Agregó el caso base no compensado.
2019-04-28 Orga Puntos
2019-04-28 rm OrgaPuntos vacio
2019-04-28 Archivos de simulación de base listos.
2019-04-28 Cambios Compensaciones
2019-04-28 Add Amortizaciones
2019-04-28 Enumero Puntos
2019-04-28 P1,2,5,6,9,10,13,14,17,18
2019-04-28 Puntos 3,7,11,15,19
2019-04-28 Puntos 4,8,12,16,20
2019-04-28 Corrección de fase.
2019-04-28 Punto 1 RF
2019-04-28 Agrego respuesta simulación de respuesta en frecuencia para los casos sin compensar y ya compensado.
2019-04-28 Renombro archos de simulaciones base.
2019-04-28 Renombro los archivos de simulación de lazo abierto.
2019-04-28 P01 LOOP y RF
2019-04-28 Add C17 P1-20*_LOOP
2019-04-28 Add RFs
2019-04-28 Correciones.
2019-04-29 Punto 1 paramétrico.
2019-04-29 Agrego explicación cualitativa.
2019-04-30 Separo simulaciones en tensión y corriente.
2019-05-01 Agrego simulación de salto de carga.
2019-05-01 Reorganizando.
2019-05-01 LOOP+RF+STEP 1A 10V
2019-05-01 Agrego primer paramétrico de CComp.
2019-05-01 Agrego paramétrico de Ccomp en lazo cerrado.
2019-05-02 Agrego la primer simulación de los saltos de carga.
2019-05-02 Cambio tiempos
2019-05-02 Agrego lazo de corriente.
2019-05-02 Agrego simulación para CComp3.
2019-05-02 Agrego la sim. para el lazo de corriente.
2019-05-02 Reordeno las simulaciones.
2019-05-03 Reorganizando las simulaciones.
2019-05-03 Agrego las sim. de Ccomp.
2019-05-05 Organizacion TP1B
2019-05-05 Agrego simulaciones temporales para Ccomp.
2019-05-05 Agrego un listado de puntos tentativo.
2019-05-05 Esquema del informe.
2019-05-06 Agrego Ccomp corriente.
2019-05-06 Init Ccomp3
2019-05-06 Ccomp3 Modo 3 RF
2019-05-06 Ccomp3 Modo 4 LOOP
2019-05-06 Ccomp3 Modo 4 RF
2019-05-06 Ccomp3 STEP 0.5n 1n 5n
2019-05-06 Ccomp3 STEP 0.5n 1n 5n Modo4
2019-05-06 Agrego algunos script de MATLAB.
2019-05-06 Inicio el informe. Trabajando en los acripts de MATLAB.
2019-05-07 Comp4 Rcomp4 Corriente
2019-05-07 Sigo con los scripts de MATLAB.
2019-05-07 Agrego avances de los scripts.
2019-05-08 Agrego scripts y correcciones.
2019-05-09 Agrego las simulaciones para Ccomp en tensión.
2019-05-09 Correcciones a todas las simulaciones y modificaciones por consistencia.
2019-05-09 Todas las simulaciones listas, resta verificarlas.
2019-05-10 Correcciones a los scripts.
2019-05-10 Correcciones. Hay que ajustar los límites de los gráficos.
2019-05-11 Imágenes finales para CComp.
2019-05-11 Agrego simulaciones de Ccomp4.
2019-05-11 Listos todos los gráficos de los capacitores.
2019-05-12 Agrego gráficos completos corregidos.
2019-05-12 Empezando el contenido del informe.
2019-05-12 Corrección de gráficos y avance del informe.
2019-05-13 Completa las explicaciones de las redes de la 1 a la 4.
2019-05-13 Agrego la explicación del snubber y la introducción a las simulaciones.
2019-05-13 Agregado Análisis para Ccomp en modo tensión, Vout = 10V.
2019-05-13 Completo Ccomp.
2019-05-13 TP1B casi completo, solo faltan los comentarios de cada modo para componente, solo hay un par que escribió Adrián.
2019-05-13 Terminado.
2019-05-15 Agrego lo hecho por Daniel al repo.
2019-05-15 Agrego el Manual y el informe de Daniel.
2019-05-15 Create Daniel2
2019-05-15 ültima versión del informe de Daniel.
2019-05-15 ültimo informe de Daniel.
2019-05-15 Última versión de lo de Daniel.
2019-05-15 Empiezo a editar las simulaciones.
2019-05-15 Completo el reorganizado del circuito de la simulación.
2019-05-16 Agregados de Daniel.
2019-05-16 Subo hasta el punto 4.
2019-05-17 Simulaciones hasta el P11d.
2019-05-17 Inicio directorio para TP final.
2019-05-17 Agregados.
2019-05-17 Clase G Basico
2019-05-17 Completas las simulaciones para BW from Rise Time y Slew Rate.
2019-05-20 Simulaciones completas.
2019-05-20 Agrego scripts de MATLAB.
2019-05-22 Correcciones a las simulaciones.
2019-05-22 Informe parcial. Falta volcar una parte.
2019-05-23 Especificaciones
2019-05-24 TP completo.
2019-05-25 Clase G v2
2019-05-28 Avances Clase G
2019-06-01 Simulación componentes reales.
2019-06-02 Subo mi versión inicial del amplificador casi completo, falta protección, compensar, etc.
2019-06-02 Muevo el directorio.
2019-06-02 agrego hojas de datos.
2019-06-03 Links de proveedores.
2019-06-03 Versión 0.4.
2019-06-04 Amplificador version 0.4.
2019-06-04 V0.4 LOOP
2019-06-04 Agrego version 0.5, de baja tensión, 45W y muy baja distorsión.
2019-06-04 Agrego cálculo de la potencia y la excursión máxima.
2019-06-05 * Correcciones.
2019-06-07 Agrego circuito para fuente sin regulación.
2019-06-10 Versión 0.6 con regulación para estabilizar las corrientes de polarización.
2019-06-10 Correeciones.
2019-06-11 Version 0.6 completa.
2019-06-14 Versión SMD del 0.6.
2019-06-15 Renombro versión del amplificador.
2019-06-16 Agrego versión con red de Zobel e inductor de salida.
2019-06-22 Versión 0.1 del pre.
2019-06-24 Agrego simulación de la fuente de alimentación.
2019-06-25 Versión 0.2 del pre.
2019-06-25 Restauro la versión 0.1 del pre.
2019-06-26 Corrections.
2019-06-27 subo simulaciones del Pre
2019-06-28 subo version 3 del pre con seleccion de entrada
2019-06-28 RATINGS
2019-06-28 tabla
2019-06-30 Version 4 del Pre
2019-06-30 saco capacitor de mas
2019-06-30 Versión 2.0 del pre, trabajando el amp.
2019-06-30 Fuente de alimentación y preamp corregidos.
2019-06-30 Nuevo circuito del amp.
2019-07-02 Probando variantes.
2019-07-02 Testeando.
2019-07-03 Circuito propuesto.
2019-07-06 Actualización de la medición de ratings.
2019-07-07 Nueva versión con resistores TH al 1% de metal film, solo se mantiene en SMD a etaba de entrada.
2019-07-07 Versión 2.1.
2019-07-08 Subo el log de ratings "Ratings.txt".
2019-07-08 Excel con las mediciones del log
2019-07-10 Actualizo tabla
2019-07-10 Correcciones a la lista de ratings.
2019-07-11 Agrego informe para usar como template.
2019-07-14 Agrego el nuevo TP final del grupo 2.
2019-07-14 Completando el modelo 3D de la placa.
2019-07-15 PCB 3D completo.
2019-07-16 PCB.
2019-07-16 PCB del amplificador listo en altium.
2019-07-17 PCB para el preamp en Altium.
2019-07-18 PCBs completos.
2019-07-18 Agrego gerbers y preparo para sacar imágenes del cobre y otras capas de las placas.
2019-07-19 Agrego informe de prgreso del grupo 2.
2019-07-19 Agrego imágenes de las capas del PCB.
2019-07-24 Cerrando TP final.
2019-07-25 Cerrando el informe.
2019-07-26 Primera versión completa del informe final.
2019-07-28 Cierro los proyectos de Altium para puedan ser importados.
2019-07-30 Pre-amp correcciones.
2019-08-07 Informe final de mediciones.
2019-08-08 Red de zobel.
2019-11-24 Actualizando las simulaciones.
2019-12-07 REPO VIEJO - CIERRO.
2019-12-21 Elimino del repo el tp del nuevo grupo, pasa a: https://github.com/MIDORIINU/DSE-CII.git
